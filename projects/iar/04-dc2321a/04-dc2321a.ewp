# IAR project 04-dc2321a.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDiagSuppress: Pa039,Pa050,Pe767,Go005,Pa082,Pa089,Pe167,Pe550,Pe188,Pe177
  ICCARM.IExtraOptions: --no_path_in_file_macros; --enum_is_int
  ICCARM.PreInclude: ..\all_projects.iarinc
  ICCARM.CCIncludePath2: ..\..\..\src\app\04-dc2321a\; ..\..\..\src\app\common\; ..\..\..\src\inc\; ..\..\..\src\modules\clilib\; ..\..\..\src\modules\ip_applib\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: 04-dc2321a.srec
  postbuild: C:\Python27\python.exe "..\..\..\tools\dustElfToBin\dustElfToBin.py" "$TARGET_PATH$"
  ILINK.IlinkOutputFile: 04-dc2321a.out
  ILINK.IlinkConfigDefines: use_loader=1
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\Linear\DustNetworks\Eterna.icf
  ILINK.IlinkProgramEntryLabel: __reset_handler
  group app/04-dc2321a
    ../../../src/app/04-dc2321a/: app_task_cfg.h cog_display.c cog_display.h cog_driver.c cog_driver.h cog_images.c cog_images.h coulomb_counter.c coulomb_counter.h dc2321a.c dc2321a.h devices.c devices.h gui_comm.c gui_comm.h network.c network.h
  group app/common
    ../../../src/app/common/: app_cfg.h build.h cli_task.c cli_task.h loc_task.c loc_task.h Ver.h well_known_ports.h
  group inc
    ../../../src/inc/: dn_adc.h dn_api_common.h dn_api_local.h dn_api_param.h dn_channel.h dn_cli.h dn_common.h dn_errno.h dn_flash_drv.h dn_flash_info.h dn_fs.h dn_gpio.h dn_hwinfo.h dn_i2c.h dn_mem.h dn_mesh.h dn_mesh_const.h dn_onewire.h dn_pack.h dn_radio.h dn_randhw.h dn_security.h dn_spi.h dn_system.h dn_temperature.h dn_time.h dn_typedef.h dn_uart.h loader.h os_cfg.h os_cpu.h ucos_ii.h
  group lib
    ../../../src/lib/: libip_stack.a libucos_full.a
  group modules/clilib
    ../../../src/modules/clilib/: dnm_ucli.c dnm_ucli.h
  group modules/ip_applib
    ../../../src/modules/ip_applib/: dnm_local.c dnm_local.h dnm_rate_ctrl.c dnm_rate_ctrl.h dnm_service.c dnm_service.h
